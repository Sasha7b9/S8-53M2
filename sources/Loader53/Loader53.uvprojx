# Keil uVision project Loader53.uvprojx, settings and files
target Loader53 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootloaderS8-53
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus
  c misc: --cpp
  c include: .\src;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\libs;..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src\drivers;..
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BootloaderS8-53.sct
  group Display
    ./src/Display/: Colors.c Colors.h Display.c Display.h DisplayTypes.h Painter.c Painter.h PainterC.h PainterText.c PainterText.h
  group FatFS
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.c FlashDrive.h
  group HAL
    ../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fsmc.c
  group Hardware
    ./src/Hardware/: FLASH.c FLASH.h FSMC.c FSMC.h Hardware.c Hardware.h Timer.c Timer.h
  group libs
    ./src/libs/: ffconf.h startup_stm32f207xx.s stm32f2xx_hal_msp.c system_stm32f2xx.c usbh_conf.h stm32f2xx_it.c stm32f2xx_it.h stm32f4xx_hal_conf.h usbh_diskio.h usbh_conf.c usbh_diskio.c
  group Panel
    ./src/Panel/: Controls.c Controls.h Panel.c Panel.h
  group Settings
    ./src/Settings/: Settings.c Settings.h SettingsTypes.h
  group src
    ./src/: main.c main.h defines.h globals.c globals.h defines.c
  group USBH
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utils
    ./src/Utils/: GlobalFunctions.c GlobalFunctions.h Math.c Math.h
  group Display/fonts
    ./src/Display/font/: Font.c Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
